# Keil uVision project 1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 1 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: Startup.s oled.c nAsciidot.h
  group LM3S_Lib
    D:/Keil4/ARM/RV31/LIB/Luminary/: DriverLib.lib
  group TimerInt
    ./: main.c systemInit.c systemInit.h all.h
