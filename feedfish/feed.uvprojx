# Keil uVision project feed.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1756 NXP
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x4000) IRAM2(0x2007C000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: feed +hex
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  scatter file: feed.sct
  group Source Group 1
    ./: main.c DS18B20.c
  group ::CMSIS Driver
    C:/Keil_v5/ARM/PACK/Keil/LPC1700_DFP/2.0.0/RTE_Driver/: UART_LPC17xx.c I2C_LPC17xx.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/LPC1700_DFP/2.0.0/RTE_Driver/: GPIO_LPC17xx.c PIN_LPC17xx.c GPDMA_LPC17xx.c
    RTE/Device/LPC1756/: RTE_Device.h startup_LPC17xx.s system_LPC17xx.c
software components: CMSIS:CORE 3.30.0, CMSIS Driver:I2C 2.01, CMSIS Driver:USART 2.01, Device:GPDMA 1.00, Device:GPIO 1.00, Device:PIN 1.00, Device:Startup 1.0.0
