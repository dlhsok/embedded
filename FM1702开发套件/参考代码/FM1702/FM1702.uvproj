# Keil uVision project FM1702.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: FM1702 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: FM1702.C 12864.c
